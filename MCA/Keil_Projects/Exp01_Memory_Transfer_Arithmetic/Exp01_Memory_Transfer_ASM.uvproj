# Keil uVision project Exp01_Memory_Transfer_ASM.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: Exp01_Memory_Transfer_ASM +hex
  c flags: Optim=1
  group Source Group 1
    ./: memory_ops.asm
