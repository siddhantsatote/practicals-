# Keil uVision project Exp09_UART_Serial_Communication_C.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: Exp09_UART_Serial_Communication_C +hex
  c flags: Optim=1
  group Source Group 1
    ./: main.c
