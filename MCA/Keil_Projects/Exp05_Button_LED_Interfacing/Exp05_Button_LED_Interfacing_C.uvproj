# Keil uVision project Exp05_Button_LED_Interfacing_C.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: Exp05_Button_LED_Interfacing_C +hex
  c flags: Optim=1
  group Source Group 1
    ./: main.c
