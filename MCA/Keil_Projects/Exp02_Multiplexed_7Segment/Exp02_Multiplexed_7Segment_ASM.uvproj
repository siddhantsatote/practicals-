# Keil uVision project Exp02_Multiplexed_7Segment_ASM.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: Exp02_Multiplexed_7Segment_ASM +hex
  c flags: Optim=1
  group Source Group 1
    ./: seven_seg.asm
